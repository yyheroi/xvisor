## arch/arm/configs/rk3568-defconfig
```kconfig
CONFIG_ARM_ARCH=armv8
CONFIG_ARM_BOARD=rk3568
CONFIG_ARM_GENERIC_TIMER=y
CONFIG_ARM_GIC_V3=y
```
